# Keil uVision project WhuFlyCar.uvprojx, settings and files
target delivery_medicine_car (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WhuFlyCar +hex
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FreeRTOS\include;..\FreeRTOS\portable\GCC\ARM_CM3;..\Drivers;..\Basic;..\Drivers;..\Communication
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.cpp stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group README
    ../: README.TXT
  group Drivers
    ../Drivers/: drv_LED.cpp drv_Main.cpp drv_LCD.cpp drv_Key.cpp self_filter.c mpuiic.c MPU6050.c inv_mpu_dmp_motion_driver.c inv_mpu.c drv_PWMOut.cpp drv_Encoder.cpp adc.c drv_Uart1.cpp drv_beep.cpp drv_beep.h control.cpp control.h drv_hcsr04.cpp drv_hcsr04.h drv_Uart3.cpp drv_Uart3.hpp
  group Basic
    ../Basic/: Basic.cpp Font.cpp GUI.cpp GUI_Images.cpp
  group Communication
    ../Communication/: Commulink.cpp
